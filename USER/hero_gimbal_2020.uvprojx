# Keil uVision project hero_gimbal_2020.uvprojx, settings and files
target hero_gimbal_2020 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Scu_Rm2018 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\FWLIB\inc;..\include\bsp;..\include\system;..\freeRTOS\include;..\freeRTOS\portable\RVDS\ARM_CM4F;..\include\tasks;..\USMART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../: readme.txt
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group system
    ../src/system/: delay.c visualscope.c pid_regulator.c ramp.c sys.c data_fifo.c iwdg.c
  group CORE
    ../CORE/: startup_stm32f427xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_can.c stm32f4xx_spi.c fifo.h RMLib.lib stm32f4xx_adc.c stm32f4xx_iwdg.c
  group tasks
    ../src/tasks/: control_task.c judge_task.c init_task.c can_task.c command_task.c monitor_task.c
  group bsp
    ../src/bsp/: beep.c key.c led.c dbus.c gun.c laser.c spi.c timer.c usart6.c imu.c adc.c usart2.c can.c usart3.c power.c uart7.c uart8.c bsp.c
  group freeROTS_CORE
    ../freeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freeRTOS_PORTABLE
    ../freeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../freeRTOS/portable/MemMang/: heap_4.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
